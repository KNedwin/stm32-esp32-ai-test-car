## esp32/esp32_tts_rtos/sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
CONFIG_LIBC_NEWLIB=y
# CONFIG_LIBC_PICOLIBC is not set
```
